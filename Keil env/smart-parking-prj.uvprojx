# Keil uVision project smart-parking-prj.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smart-parking-prj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c include: ..\App;..\Drivers;..\IPC;..\Common Resources\Required_Files;..\Common Resources
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ../App/: gate_controller.c gate_fsm.c main.c safety_monitor.c led_task.c input_task.c
  group Drivers
    ../Drivers/: button_driver.c led_driver.c uart_driver.c
  group IPC
    ../IPC/: shared_queues.c
  group Common Resources
    ../Common Resources/Required_Files/: basic_io.c consoleprint.c retarget.c
software components: RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, CMSIS:CORE 6.2.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, Device:Startup 1.0.1
